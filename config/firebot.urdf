Commit message: rename package to be shorter

File: config/firebot.urdf (robot description, URDF)
Before this commit: robot fire_fighter, 5 links, 4 joints
Links:
- link top_deck_link: geometry visual mesh filename=package://firebot/config/top_deck.stl scale=0.001 0.001 0.001
